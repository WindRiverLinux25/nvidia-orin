do_install:prepend:nvidia-orin() {
    install -d ${D}${datadir}/tegraflash
}
