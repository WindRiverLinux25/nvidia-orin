COMPATIBLE_MACHINE:nvidia-orin = "nvidia-orin"
