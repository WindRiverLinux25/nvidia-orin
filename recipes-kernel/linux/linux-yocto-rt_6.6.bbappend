#
# Copyright (C) 2023 Wind River Systems, Inc.
#

require linux-yocto-tegra.inc

COMPATIBLE_MACHINE:nvidia-orin = "nvidia-orin"

KBRANCH:nvidia-orin  = "v6.6/standard/preempt-rt/nvidia-orin"
KMACHINE:nvidia-orin = "nvidia-orin"

