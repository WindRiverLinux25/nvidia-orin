require linux-yocto-nvidia-orin.inc

KBRANCH:nvidia-orin = "v6.12/standard/preempt-rt/nvidia-sdk-5.15/nvidia-soc"
