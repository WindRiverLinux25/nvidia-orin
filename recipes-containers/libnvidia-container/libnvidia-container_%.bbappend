EXTRA_OEMAKE:append:nvidia-orin = " LIB_VERSION=${PV}"
